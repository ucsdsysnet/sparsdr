<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pluto_single_channel</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Pluto single-channel reconstruct</value></param>
</block>
<block>
<key>variable_sparsdr_reconstruct</key>
<param><key>id</key><value>variable_sparsdr_reconstruct_0</value></param>
<param><key>band_0_bins</key><value>64</value></param>
<param><key>band_0_frequency</key><value>26e6</value></param>
<param><key>band_1_bins</key><value>2048</value></param>
<param><key>band_1_frequency</key><value>0.0</value></param>
<param><key>band_10_bins</key><value>2048</value></param>
<param><key>band_10_frequency</key><value>0.0</value></param>
<param><key>band_11_bins</key><value>2048</value></param>
<param><key>band_11_frequency</key><value>0.0</value></param>
<param><key>band_12_bins</key><value>2048</value></param>
<param><key>band_12_frequency</key><value>0.0</value></param>
<param><key>band_13_bins</key><value>2048</value></param>
<param><key>band_13_frequency</key><value>0.0</value></param>
<param><key>band_14_bins</key><value>2048</value></param>
<param><key>band_14_frequency</key><value>0.0</value></param>
<param><key>band_15_bins</key><value>2048</value></param>
<param><key>band_15_frequency</key><value>0.0</value></param>
<param><key>band_16_bins</key><value>2048</value></param>
<param><key>band_16_frequency</key><value>0.0</value></param>
<param><key>band_17_bins</key><value>2048</value></param>
<param><key>band_17_frequency</key><value>0.0</value></param>
<param><key>band_18_bins</key><value>2048</value></param>
<param><key>band_18_frequency</key><value>0.0</value></param>
<param><key>band_19_bins</key><value>2048</value></param>
<param><key>band_19_frequency</key><value>0.0</value></param>
<param><key>band_2_bins</key><value>2048</value></param>
<param><key>band_2_frequency</key><value>0.0</value></param>
<param><key>band_20_bins</key><value>2048</value></param>
<param><key>band_20_frequency</key><value>0.0</value></param>
<param><key>band_21_bins</key><value>2048</value></param>
<param><key>band_21_frequency</key><value>0.0</value></param>
<param><key>band_22_bins</key><value>2048</value></param>
<param><key>band_22_frequency</key><value>0.0</value></param>
<param><key>band_23_bins</key><value>2048</value></param>
<param><key>band_23_frequency</key><value>0.0</value></param>
<param><key>band_24_bins</key><value>2048</value></param>
<param><key>band_24_frequency</key><value>0.0</value></param>
<param><key>band_25_bins</key><value>2048</value></param>
<param><key>band_25_frequency</key><value>0.0</value></param>
<param><key>band_26_bins</key><value>2048</value></param>
<param><key>band_26_frequency</key><value>0.0</value></param>
<param><key>band_27_bins</key><value>2048</value></param>
<param><key>band_27_frequency</key><value>0.0</value></param>
<param><key>band_28_bins</key><value>2048</value></param>
<param><key>band_28_frequency</key><value>0.0</value></param>
<param><key>band_29_bins</key><value>2048</value></param>
<param><key>band_29_frequency</key><value>0.0</value></param>
<param><key>band_3_bins</key><value>2048</value></param>
<param><key>band_3_frequency</key><value>0.0</value></param>
<param><key>band_30_bins</key><value>2048</value></param>
<param><key>band_30_frequency</key><value>0.0</value></param>
<param><key>band_31_bins</key><value>2048</value></param>
<param><key>band_31_frequency</key><value>0.0</value></param>
<param><key>band_4_bins</key><value>2048</value></param>
<param><key>band_4_frequency</key><value>0.0</value></param>
<param><key>band_5_bins</key><value>2048</value></param>
<param><key>band_5_frequency</key><value>0.0</value></param>
<param><key>band_6_bins</key><value>2048</value></param>
<param><key>band_6_frequency</key><value>0.0</value></param>
<param><key>band_7_bins</key><value>2048</value></param>
<param><key>band_7_frequency</key><value>0.0</value></param>
<param><key>band_8_bins</key><value>2048</value></param>
<param><key>band_8_frequency</key><value>0.0</value></param>
<param><key>band_9_bins</key><value>2048</value></param>
<param><key>band_9_frequency</key><value>0.0</value></param>
<param><key>band_count</key><value>1</value></param>
<param><key>compressed_format</key><value>Pluto v1</value></param>
<param><key>reconstruct_path</key><value>sparsdr_reconstruct</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>64.0 / 1024.0 * 61.44e6</value></param>
<param><key>fc</key><value>2.426e9</value></param>
<param><key>fftsize</key><value>64</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>sparsdr_compressing_pluto_source</key>
<param><key>id</key><value>sparsdr_compressing_pluto_source_0</value></param>
<param><key>average_interval</key><value>2 ** 16</value></param>
<param><key>bin_spec</key><value>416..450:12800</value></param>
<param><key>buffer_size</key><value>1024 * 16</value></param>
<param><key>frequency</key><value>int(2.4e9)</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>gain</key><value>60</value></param>
<param><key>uri</key><value>ip:192.168.2.1</value></param>
<param><key>shift_amount</key><value>6</value></param>
</block>
<connection><source_block_id>blocks_probe_rate_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rate</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sparsdr_compressing_pluto_source_0</source_block_id><sink_block_id>blocks_probe_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sparsdr_compressing_pluto_source_0</source_block_id><sink_block_id>variable_sparsdr_reconstruct_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>variable_sparsdr_reconstruct_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
